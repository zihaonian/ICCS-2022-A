# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\test;..\..\ICCS;.\my_lib\DCmotor;.\my_lib\Delay;.\my_lib\DS1302;.\my_lib\DS18B20;.\my_lib\int;.\my_lib\IR;.\my_lib\LCD12864;.\my_lib\LCD1602;.\my_lib\MatrixKey;.\my_lib\OneWire;.\my_lib\Timer;.\my_lib\XPT2046
  group user
    ./user/: main.c
  group my_lib
    ./my_lib/DCmotor/: DCmotor.c
    ./my_lib/Delay/: Delay.c
    ./my_lib/DS18B20/: DS18B20.c
    ./my_lib/DS1302/: DS1302.c
    ./my_lib/int/: int.c Int0.c
    ./my_lib/IR/: IR.c
    ./my_lib/LCD1602/: LCD1602.c
    ./my_lib/LCD12864/: LCD12864.c
    ./my_lib/MatrixKey/: MatrixKey.c
    ./my_lib/OneWire/: OneWire.c
    ./my_lib/Timer/: Timer.c Timer0.c
    ./my_lib/XPT2046/: XPT2046.c
